# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c STC8G.h Type_def.h Config.h OLED.c OLED.h OLED_CONT.h CK.c CK.h Delay.c Delay.h Dht.c Dht.h GPIO.c GPIO.h
